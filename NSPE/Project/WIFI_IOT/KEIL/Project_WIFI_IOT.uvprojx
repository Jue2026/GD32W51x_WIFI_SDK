# Keil uVision project Project_WIFI_IOT.uvprojx, settings and files
target Project_Freertos_Mbedtls3.x (6090000::V6.9::.\ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x70000) IRAM2(0x30000000,0x70000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: nspe
  BeforeMake: ..\build_date.bat ..\..\..\
  AfterMake: ..\nspe_afterbuild.bat $L KEIL $K
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: PLATFORM_OS_FREERTOS
  c misc: -fshort-wchar
  c include: ..\..\..\Firmware\CMSIS\DSP_Lib_v1.16.2\include;..\..\..\Firmware\CMSIS\GD\GD32W51x\Include;..\..\..\Firmware\GD32W51x_standard_peripheral\Include;..\..\..\Firmware\GD32W51x_wifi_driver\inc;..\..\..\Firmware\GD32W51x_wifi_driver\osal;..\..\..\Firmware\GD32W51x_wifi_driver\cmn;..\..\..\Firmware\GD32W51x_wifi_driver\soc;..\..\..\WIFI_IOT\app;..\..\..\WIFI_IOT\bsp;..\..\..\WIFI_IOT\wifi;..\..\..\WIFI_IOT\os;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\Source\include;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\Source\portable\Keil\ARM_CM33_NTZ;..\..\..\WIFI_IOT\network\lwip\apps;..\..\..\WIFI_IOT\network\lwip\port;..\..\..\WIFI_IOT\network\lwip\src\include;..\..\..\WIFI_IOT\network\lwip\src\include\lwip;..\..\..\WIFI_IOT\network\lwip\port\arch;..\..\..\WIFI_IOT\network\mbedtls\include;..\..\..\WIFI_IOT\network\mbedtls\library;..\..\..\WIFI_IOT\network\iperf3;..\..\..\WIFI_IOT\FatFS;..\..\..\WIFI_IOT\FatFS\src;..\..\..\..\config;..\..\..\..\ROM-EXPORT\source;..\..\..\..\ROM-EXPORT\platform;..\..\..\..\MBL\platform;..\..\..\..\MBL\source;..\..\..\..\MBL\source_ns;..\..\..\..\PROT\trusted-firmware-m\interface\include;..\..\..\..\PROT\mbedtls_ns_callable;..\..\..\WIFI_IOT\demo;..\..\..\WIFI_IOT\common;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\CMSIS\RTOS2\FreeRTOS\Include;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\CMSIS\RTOS2\FreeRTOS\Source;..\..\..\WIFI_IOT\app\mqtt_app;..\..\..\WIFI_IOT\cloud\alicloud\examples\linkkit\living_platform;..\..\..\WIFI_IOT\cloud\alicloud\include;..\..\..\WIFI_IOT\cloud\alicloud\include\exports;..\..\..\WIFI_IOT\cloud\alicloud\include\imports;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\digest;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\log;..\..\..\WIFI_IOT\cloud\alicloud\src\ref-impl\hal;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\kv;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\misc;..\..\..\WIFI_IOT\cloud\alicloud\src\ref-impl\hal\os\freertos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
  scatter file: .\Project.sct
  link misc: --predefine="-DPLATFORM_OS_FREERTOS"
  group Alicloud
    ../../../WIFI_IOT/cloud/alicloud/src/ref-impl/hal/os/freertos/: hal_awss_gd.c hal_crypto_gd.c hal_kv_gd.c hal_os_gd.c hal_ota_gd.c hal_product_gd.c hal_system_gd.c hal_tcp_gd.c hal_tls_gd.c hal_udp_gd.c hal_wifi_gd.c
    ../../../WIFI_IOT/cloud/alicloud/examples/linkkit/living_platform/: alicloud_entry.c living_platform_awss_reset.c living_platform_main.c living_platform_ut.c
  group Application
    ../../../WIFI_IOT/app/: cmd_shell.c console.c main.c
  group Armdsp
    ../../../Firmware/CMSIS/DSP_Lib_v1.16.2/source/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_radix2_f32.c arm_cfft_radix4_f32.c arm_cfft_radix8_f32.c arm_common_tables.c arm_const_structs.c arm_cos_f32.c arm_sin_cos_f32.c arm_sin_f32.c arm_bitreversal2.c
  group Bsp
    ../../../WIFI_IOT/bsp/: bsp_wlan.c dma.c init_rom.c rf_efuse.c uart.c gd32_it.c trng.c
  group Common
    ../../../WIFI_IOT/common/: cJSON.c debug_print.c delay.c dlist.c malloc.c wakelock.c wrapper_os.c
  group Demo
    ../../../WIFI_IOT/demo/: iperf3_main.c ota_demo.c ssl_client.c tcp_test.c udp_test.c telnet_main.c telnetserver.c
    ../../../WIFI_IOT/app/mqtt_app/: mqtt_cmd.c
    ../../../WIFI_IOT/network/lwip/port/: dnsd.c
  group FatFS
    ../../../WIFI_IOT/FatFS/src/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../WIFI_IOT/FatFS/: fatfs.c wear_levelling_flash.c
  group Freertos
    ../../../WIFI_IOT/os/FreeRTOSv10.5.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../WIFI_IOT/os/FreeRTOSv10.5.1/Source/portable/Keil/ARM_CM33_NTZ/: port.c portasm.c portasm.asm
    ../../../WIFI_IOT/os/FreeRTOSv10.5.1/Source/portable/Common/: tickless_sleep.c
    ../../../WIFI_IOT/os/FreeRTOSv10.5.1/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c freertos_evr.c os_systick.c
    ../../../WIFI_IOT/os/FreeRTOSv10.5.1/CMSIS/RTOS2/FreeRTOS/Source/ARM/: clib_arm.c
  group Library
    ../../../../ROM-EXPORT/symbol/: rom_symbol_mbedtls_20200709
    ../../../WIFI_IOT/lib/KEIL/: alicloud.lib Iperf3.lib wlan.lib rftest.lib
  group Lwip
    ../../../WIFI_IOT/network/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../WIFI_IOT/network/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../WIFI_IOT/network/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c acd.c
    ../../../WIFI_IOT/network/lwip/src/netif/: ethernet.c
    ../../../WIFI_IOT/network/lwip/port/: dhcpd.c ethernetif.c sys_arch.c wifi_netif.c httpd_post.c
    ../../../WIFI_IOT/network/lwip/apps/ping/: ping.c
    ../../../WIFI_IOT/network/lwip/src/core/ipv6/: ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c icmp6.c dhcp6.c ethip6.c
    ../../../WIFI_IOT/network/lwip/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c
    ../../../WIFI_IOT/network/lwip/apps/mqtt/: mqtt.c mqtt5.c
    ../../../WIFI_IOT/network/lwip/apps/http/: fs.c httpd.c
  group Mbedtls
    ../../../WIFI_IOT/network/mbedtls-2.17.0-ssl/library/: debug.c net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_default_conf.c ssl_self_test.c ssl_srv.c ssl_ticket.c ssl_tls.c
    ../../../WIFI_IOT/network/mbedtls-2.17.0-ssl/ns_interface/: mbedtls_ns_function_api.c ns_interface.c
  group Mbedtls3.x
    ../../../WIFI_IOT/network/mbedtls/library/: aes.c aes_alt.c aesce.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c des_alt.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c lmots.c lms.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkcs7.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha3.c sha256.c sha256_alt.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
    ../../../WIFI_IOT/network/mbedtls/programs/test/: selftest.c
  group Peripherals
    ../../../Firmware/CMSIS/GD/GD32W51x/Source/ARM/: startup_gd32w51x.s
    ../../../Firmware/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
    ../../../Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_adc.c gd32w51x_cau.c gd32w51x_cau_aes.c gd32w51x_cau_des.c gd32w51x_cau_tdes.c gd32w51x_crc.c gd32w51x_dbg.c gd32w51x_dci.c gd32w51x_dma.c gd32w51x_efuse.c gd32w51x_exti.c gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_hau.c gd32w51x_hau_sha_md5.c gd32w51x_hpdf.c gd32w51x_i2c.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_pkcau.c gd32w51x_pmu.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_rtc.c gd32w51x_sdio.c gd32w51x_spi.c gd32w51x_sqpi.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_trng.c gd32w51x_tsi.c gd32w51x_tzpcu.c gd32w51x_usart.c gd32w51x_wwdgt.c
  group Wifi
    ../../../WIFI_IOT/wifi/: wifi_eloop.c wifi_management.c wifi_netlink.c wifi_softap_provisioning.c wpas_sae_crypto_mbedtls.c
  group Rtthread
    ../../../WIFI_IOT/os/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c memheap.c object.c thread.c timer.c scheduler_up.c
    ../../../WIFI_IOT/os/rt-thread/libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
    ../../../WIFI_IOT/os/rt-thread/bsp/gd32w51x/drivers/: board.c
    ../../../WIFI_IOT/os/rt-thread/components/drivers/pm/: pm.c pm_sleep.c lptimer.c
target Project_Freertos (6090000::V6.9::.\ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.3
  cpu: as above
  output: nspe
  BeforeMake: ..\build_date.bat ..\..\..\
  AfterMake: ..\nspe_afterbuild.bat $L KEIL $K
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: PLATFORM_OS_FREERTOS
  c misc: -fshort-wchar
  c include: ..\..\..\Firmware\CMSIS\DSP_Lib_v1.16.2\include;..\..\..\Firmware\CMSIS\GD\GD32W51x\Include;..\..\..\Firmware\GD32W51x_standard_peripheral\Include;..\..\..\Firmware\GD32W51x_wifi_driver\inc;..\..\..\Firmware\GD32W51x_wifi_driver\osal;..\..\..\Firmware\GD32W51x_wifi_driver\cmn;..\..\..\Firmware\GD32W51x_wifi_driver\soc;..\..\..\WIFI_IOT\app;..\..\..\WIFI_IOT\bsp;..\..\..\WIFI_IOT\wifi;..\..\..\WIFI_IOT\os;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\Source\include;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\Source\portable\Keil\ARM_CM33_NTZ;..\..\..\WIFI_IOT\network\lwip\apps;..\..\..\WIFI_IOT\network\lwip\port;..\..\..\WIFI_IOT\network\lwip\src\include;..\..\..\WIFI_IOT\network\lwip\src\include\lwip;..\..\..\WIFI_IOT\network\lwip\port\arch;..\..\..\WIFI_IOT\network\mbedtls-2.17.0-ssl\include;..\..\..\WIFI_IOT\network\mbedtls-2.17.0-ssl\ns_interface;..\..\..\WIFI_IOT\network\iperf3;..\..\..\WIFI_IOT\FatFS;..\..\..\WIFI_IOT\FatFS\src;..\..\..\..\config;..\..\..\..\ROM-EXPORT\source;..\..\..\..\ROM-EXPORT\platform;..\..\..\..\MBL\platform;..\..\..\..\MBL\source;..\..\..\..\MBL\source_ns;..\..\..\..\PROT\trusted-firmware-m\interface\include;..\..\..\..\PROT\mbedtls_ns_callable;..\..\..\WIFI_IOT\demo;..\..\..\WIFI_IOT\common;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\CMSIS\RTOS2\FreeRTOS\Include;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\CMSIS\RTOS2\FreeRTOS\Source;..\..\..\WIFI_IOT\app\mqtt_app;..\..\..\WIFI_IOT\cloud\alicloud\examples\linkkit\living_platform;..\..\..\WIFI_IOT\cloud\alicloud\include;..\..\..\WIFI_IOT\cloud\alicloud\include\exports;..\..\..\WIFI_IOT\cloud\alicloud\include\imports;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\digest;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\log;..\..\..\WIFI_IOT\cloud\alicloud\src\ref-impl\hal;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\kv;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\misc;..\..\..\WIFI_IOT\cloud\alicloud\src\ref-impl\hal\os\freertos;..\..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
  scatter file: .\Project.sct
  link misc: --predefine="-DPLATFORM_OS_FREERTOS"
target Project_Rtthread (6090000::V6.9::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: nspe
  BeforeMake: ..\build_date.bat ..\..\..\
  AfterMake: ..\nspe_afterbuild.bat $L KEIL $K
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_OS_RTTHREAD
  c misc: -fshort-wchar
  c include: ..\..\..\Firmware\CMSIS\DSP_Lib_v1.16.2\include;..\..\..\Firmware\CMSIS\GD\GD32W51x\Include;..\..\..\Firmware\GD32W51x_standard_peripheral\Include;..\..\..\Firmware\GD32W51x_wifi_driver\inc;..\..\..\Firmware\GD32W51x_wifi_driver\osal;..\..\..\Firmware\GD32W51x_wifi_driver\cmn;..\..\..\Firmware\GD32W51x_wifi_driver\soc;..\..\..\WIFI_IOT\app;..\..\..\WIFI_IOT\app\mqtt_app;..\..\..\WIFI_IOT\bsp;..\..\..\WIFI_IOT\common;..\..\..\WIFI_IOT\demo;..\..\..\WIFI_IOT\wifi;..\..\..\WIFI_IOT\os;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\Source\include;..\..\..\WIFI_IOT\os\FreeRTOSv10.5.1\Source\portable\Keil\ARM_CM33_NTZ;..\..\..\WIFI_IOT\network\lwip\apps;..\..\..\WIFI_IOT\network\lwip\port;..\..\..\WIFI_IOT\network\lwip\src\include;..\..\..\WIFI_IOT\network\lwip\src\include\lwip;..\..\..\WIFI_IOT\network\lwip\port\arch;..\..\..\WIFI_IOT\network\mbedtls-2.17.0-ssl\include;..\..\..\WIFI_IOT\network\mbedtls-2.17.0-ssl\ns_interface;..\..\..\WIFI_IOT\network\iperf3;..\..\..\WIFI_IOT\cloud\alicloud;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\infra;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\dev_model;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wrappers;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src;..\..\..\WIFI_IOT\cloud\alicloud\iotkit-embedded-3.2.0\lib_iot_sdk_src\eng\wifi_provision;..\..\..\WIFI_IOT\FatFS;..\..\..\WIFI_IOT\FatFS\src;..\..\..\..\config;..\..\..\..\ROM-EXPORT\source;..\..\..\..\ROM-EXPORT\platform;..\..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include;..\..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include\mbedtls;..\..\..\..\MBL\platform;..\..\..\..\MBL\source;..\..\..\..\MBL\source_ns;..\..\..\..\PROT\trusted-firmware-m\interface\include;..\..\..\..\PROT\mbedtls_ns_callable;..\..\..\WIFI_IOT\os\rt-thread\include;..\..\..\WIFI_IOT\os\rt-thread\components\drivers\include;..\..\..\WIFI_IOT\os\rt-thread\components\drivers\pm;..\..\..\WIFI_IOT\os\rt-thread\bsp\gd32w51x;..\..\..\WIFI_IOT\os\rt-thread\bsp\gd32w51x\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Project.sct
  link misc: --predefine="-DPLATFORM_OS_RTTHREAD"
software components: CMSIS:CORE 5.1.1
