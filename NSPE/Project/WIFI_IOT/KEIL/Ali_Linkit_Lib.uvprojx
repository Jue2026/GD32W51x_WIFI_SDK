# Keil uVision project Ali_Linkit_Lib.uvprojx, settings and files
target ali_linkit_sdk (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: alicloud (library)
  AfterMake: cmd /c copy .\alicloud\alicloud.lib ..\..\..\WIFI_IOT\lib\KEIL\
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_TLS,COAP_SERV_MULTITHREAD,AWSS_SUPPORT_APLIST,MQTT_AUTO_SUBSCRIBE,MQTT_COMM_ENABLED,DEVICE_MODEL_ENABLED,DEV_BIND_ENABLED,OTA_ENABLED,WIFI_PROVISION_ENABLED,AWSS_SUPPORT_DEV_AP,AWSS_SUPPORT_SMARTCONFIG
  c misc: --diag_suppress=1295 --diag_suppress=111
  c include: ..\..\..\WIFI_IOT\common;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\log;..\..\..\WIFI_IOT\cloud\alicloud\include;..\..\..\WIFI_IOT\cloud\alicloud\include\imports;..\..\..\WIFI_IOT\cloud\alicloud\include\exports;..\..\..\WIFI_IOT\cloud\alicloud\src\services\dev_bind;..\..\..\WIFI_IOT\cloud\alicloud\src\services\ota;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\system;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\kv;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\misc;..\..\..\WIFI_IOT\cloud\alicloud\src\infra\utils\digest;..\..\..\WIFI_IOT\cloud\alicloud\src\protocol\alcs;..\..\..\WIFI_IOT\cloud\alicloud\src\protocol\coap\local;..\..\..\WIFI_IOT\cloud\alicloud\src\protocol\mqtt;..\..\..\WIFI_IOT\cloud\alicloud\src\protocol\mqtt\MQTTPacket;..\..\..\WIFI_IOT\cloud\alicloud\src\ref-impl\hal\os\freertos;..\..\..\WIFI_IOT\cloud\alicloud\src\services\awss;..\..\..\WIFI_IOT\cloud\alicloud\src\services\shadow;..\..\..\WIFI_IOT\cloud\alicloud\src\services\dev_diagnosis;..\..\..\WIFI_IOT\cloud\alicloud\src\services\dev_bind\os;..\..\..\WIFI_IOT\cloud\alicloud\src\services\linkkit\cm;..\..\..\WIFI_IOT\cloud\alicloud\src\services\linkkit\dev_reset;..\..\..\WIFI_IOT\cloud\alicloud\src\services\linkkit\cm\include;..\..\..\WIFI_IOT\cloud\alicloud\src\services\linkkit\dm;..\..\..\WIFI_IOT\cloud\alicloud\src\services\linkkit\dm\client;..\..\..\WIFI_IOT\cloud\alicloud\src\services\linkkit\dm\server;..\..\..\WIFI_IOT\cloud\alicloud\src\services\ota;..\..\..\WIFI_IOT\cloud\alicloud\src\sdk-impl
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group alcs
    ../../../WIFI_IOT/cloud/alicloud/src/protocol/alcs/: alcs_adapter.c alcs_api.c alcs_client.c alcs_coap.c alcs_localsetup.c alcs_mqtt.c alcs_server.c
  group awss
    ../../../WIFI_IOT/cloud/alicloud/src/services/awss/: awss_adha.c awss_aha.c awss_ap_scan.c awss_aplist.c awss_crypt.c awss_dev_ap.c awss_enrollee.c awss_ht40.c awss_info.c awss_info_notify.c awss_main.c awss_manufact_ap_find.c awss_registrar.c awss_smartconfig.c awss_smartconfig_mcast.c awss_statis.c awss_wifimgr.c awss_wps.c connect_ap.c zconfig_ieee80211.c zconfig_protocol.c zconfig_utils.c zconfig_vendor_common.c awss.c awss_security.c
  group coap
    ../../../WIFI_IOT/cloud/alicloud/src/protocol/coap/local/: CoAPDeserialize.c CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPObserve.c CoAPPlatform.c CoAPResource.c CoAPSerialize.c CoAPServer.c
  group dev_bind
    ../../../WIFI_IOT/cloud/alicloud/src/services/dev_bind/: awss_bind.c awss_bind_statis.c awss_cmp_coap.c awss_cmp_mqtt.c awss_event.c awss_notify.c awss_packet.c awss_report.c awss_timer.c passwd.c sha256.c
    ../../../WIFI_IOT/cloud/alicloud/src/services/dev_bind/os/: os_misc.c
  group dev_diagnosis
    ../../../WIFI_IOT/cloud/alicloud/src/services/dev_diagnosis/: dev_diagnosis.c dev_errcode.c dev_offline_ota.c dev_state_machine.c diagnosis_offline_log.c
  group dev_reset
    ../../../WIFI_IOT/cloud/alicloud/src/services/linkkit/dev_reset/: awss_reset.c awss_reset_statis.c offline_reset.c
  group dm
    ../../../WIFI_IOT/cloud/alicloud/src/services/linkkit/dm/: dm_api.c dm_cota.c dm_fota.c dm_ipc.c dm_manager.c dm_message.c dm_message_cache.c dm_msg_process.c dm_opt.c dm_ota.c dm_shadow.c dm_utils.c
    ../../../WIFI_IOT/cloud/alicloud/src/services/linkkit/dm/server/: dm_server.c dm_server_adapter.c
    ../../../WIFI_IOT/cloud/alicloud/src/services/linkkit/dm/client/: dm_client.c dm_client_adapter.c
  group infra
    ../../../WIFI_IOT/cloud/alicloud/src/infra/log/: iotx_log.c
    ../../../WIFI_IOT/cloud/alicloud/src/infra/system/: aos_support.c ca.c device.c event.c guider.c redirect_region.c report.c
    ../../../WIFI_IOT/cloud/alicloud/src/infra/system/facility/: fac_string.c
    ../../../WIFI_IOT/cloud/alicloud/src/infra/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c utils_sha256.c
    ../../../WIFI_IOT/cloud/alicloud/src/infra/utils/kv/: aiot_kv_api.c
    ../../../WIFI_IOT/cloud/alicloud/src/infra/utils/misc/: json_parser.c json_token.c lite-cjson.c log_report.c mem_stats.c string_utils.c utils_epoch_time.c utils_event.c utils_httpc.c utils_net.c utils_timer.c
  group linkkit
    ../../../WIFI_IOT/cloud/alicloud/src/services/linkkit/cm/: iotx_cm.c iotx_cm_coap.c iotx_cm_mqtt.c
  group mqtt
    ../../../WIFI_IOT/cloud/alicloud/src/protocol/mqtt/client/: mqtt_client.c
    ../../../WIFI_IOT/cloud/alicloud/src/protocol/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group ota
    ../../../WIFI_IOT/cloud/alicloud/src/services/ota/: iotx_ota.c
    ../../../WIFI_IOT/cloud/alicloud/src/services/ota/impl/: ota_fetch.c ota_lib.c
    ../../../WIFI_IOT/cloud/alicloud/src/services/ota/prot/: ota_coap.c ota_mqtt.c
  group sdk_impl
    ../../../WIFI_IOT/cloud/alicloud/src/sdk-impl/: impl_dynreg.c impl_linkkit.c impl_logpost.c impl_ntp.c sdk_reset.c sdk-impl.c
  group shadow
    ../../../WIFI_IOT/cloud/alicloud/src/services/shadow/: shadow.c shadow_common.c shadow_delta.c shadow_update.c utils_list.c
  group util
    ../../../WIFI_IOT/cloud/alicloud/examples/: cJSON.c
